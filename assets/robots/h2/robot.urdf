Commit message: 手部关键点显示等改动

File: assets/robots/h2/robot.urdf (robot description, URDF)
Before this commit: robot H2, 34 links, 33 joints
Links:
- link right_hand_link: geometry collision mesh filename=meshes/right_hand_link.stl
